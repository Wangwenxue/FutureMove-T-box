# Keil uVision project libgeneric_FutureMove.uvproj, settings and files
target Debug (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: XXXlibrarynameXXX_FutureMove_d (library)
  AfterMake: "..\bat\XXXlibrarynameXXX_FutureMove.bat" "..\..\..\lib\FutureMove.uv4\XXXlibrarynameXXX" uv4 debug FutureMove
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  asm misc: --cpreproc --diag_suppress=1609
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\FutureMove.uv4\mqx\intflash.scf
target Release (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: XXXlibrarynameXXX_FutureMove (library)
  AfterMake: "..\bat\XXXlibrarynameXXX_FutureMove.bat" "..\..\..\lib\FutureMove.uv4\XXXlibrarynameXXX" uv4 release FutureMove
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\FutureMove.uv4\mqx\intflash.scf
